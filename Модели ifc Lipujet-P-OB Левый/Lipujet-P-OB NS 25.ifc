Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-08-12T11:29:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 12 11:29:28 2019 * Host: IN-BLR-WS-1079 * Database: C:\Users\KSUBRA~1\AppData\Local\Temp\{5912F6D5-B525-4C14-8638-56E55387F974}\ifc * Database version: 5507 * Database creation date: Mon Aug 12 11:29:28 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 12 11:29:28 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 12 11:29:28 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: std, ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO:std:298656
In: Level 0
Type - PredefinedType: USERDEFINED; Material: Plastic, White, HDPE, Red, HDPE, Black
Type - Identity Data - Manufacturer: ACO; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Name: std
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO
Pset_BuildingElementProxyCommon - Reference: std
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Constraints - filling_device: yes; grease_measure_device: no; heating_rod: no; Host: Level : Level 0; inlet_angle: 0 deg; left: yes; Level: Level: Level 0; logo: yes; Moves With Nearby Elements: no; Offset: 0 mm; right: no
Dimensions - Area: 22.331 m2; cover_D: 490 mm; cover_H: 53 mm; cover1_X: 630 mm; cover2_X: 3500 mm; DN: 200 mm; drain_D: 69 mm; drain_L: 630 mm; drain_X: 1580 mm; drain_Z: 75 mm; H1: 1850 mm; H2: 1740 mm; H3: 1300 mm; H4: 1230 mm; H5: 15 mm; H6: 524 mm; H7: 944 mm; L1: 4100 mm; L2: 3860 mm; L3: 3800 mm; L4: 3933 mm; logo_X: 2720 mm; logo_Z: 610 mm; vent_D: 110 mm; vent_H: 50 mm; vent_X: 2320 mm; vent_Y: 1000 mm; Volume: 7.43344 m3; W1: 1340 mm; W2: 1260 mm; W3: 1200 mm; W4: 390 mm; waterinlet_angle: -50 deg; waterinlet_D: 90 mm; waterinlet_L: 686 mm; waterinlet_X: 3230 mm; waterinlet_Z: 1526 mm; window1_X: 1140 mm; window1_Z: 705 mm; window2_X: 2720 mm; window2_Z: 1147 mm
General - RSen_P_c01_diameter: 200 mm; RSen_P_c02_diameter: 200 mm
Identity Data - Mark: 2
Materials and Finishes - RSen_C_material: HDPE, Black
Model Properties - grease_measure_end_angle: -85 deg; grease_measure_start_angle: -90 deg; grease_measure_X: 1810 mm; heatrod_position: -90 deg; heatrod_X: 2720 mm; heatrod_Z: 897 mm
Other - connection_radius: 100 mm; disabled_options: no; drain_position: -90 deg; Family: ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO: std; Family and Type: ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO: std; grease_measure_option: 1; heatrod_option: 1; L1_half: 2050 mm; L2_calculated: 2600 mm; logo_position: -90 deg; lookup_table_name: oval_big_lipujet_p; options_lookup_table_name: oval_big_lipujet_p_options; Type: ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO: std; type_index: 25; Type Id: ZZZ_do not use_ME_PE_UN_oval big lipujet p options_ACO: std; W3_half: 600 mm; water_inlet_end_angle: 145 deg; water_inlet_option: 1; water_inlet_start_angle: 140 deg; waterinlet_bend_calculated: 91 mm; waterinlet_H_calculated: 324 mm; window_option: 0; window_position: -90 deg
Phasing - Phase Created: New Construction

# IfcFlowController: std, ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO:std:298659
In: Level 0
Type - Description: ACO filling device; PredefinedType: FAUCET; Material: Stainless Steel, Brushed
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC010071; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_P_c01_diameter: 20 mm
Type - Identity Data - Description: ACO filling device; LOD: LOD 400; Manufacturer: ACO; Model: Filling device for LipuJet-P; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Free outlet as per DIN 1988 Part 4; Type Name: std
Type - Materials and Finishes - RSen_C_material: Stainless Steel, Brushed
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO
Type - Plumbing - p_c01_flow: 0.003 m3/s
Type - Structural - RSen_S_net_mass: 3.5
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std
Constraints - Moves With Nearby Elements: no; Level: Level: Level 0; Host: Level : Level 0; Offset: 1750 mm
Dimensions - Area: 0.0761672 m2; Volume: 0.00141803 m3
Identity Data - Mark: 5; RSen_C_code_article: 3300.11.22; RSen_C_code_gtin: 04002626299253; RSen_C_description: ACO Fülleinheit für LipuJet-P-OB,-P-OD,-P-RB,-P-RD; RSen_C_product_assortment: Grease separators
Other - Family: ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO: std; Family and Type: ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO: std; option: 1; Type: ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO: std; Type Id: ZZZ_do not use_ME_ST_WPB_filling device for LipuJet-P_ACO: std
Phasing - Phase Created: New Construction

# IfcWindow: std (2)
In: Level 0
Type - Description: ACO viewing window; ParameterTakesPrecedence: no; Sizeable: no; Material: HDPE, Red, HDPE, Black, HDPE, Grey
Type - Constraints - Default Elevation: 1219.2 mm
Type - General - RSen_C_code_ETIM: EC011162; RSen_C_code_manufacturer_gln: 4399901709010; RSen_C_content_creator: Itannex bv; RSen_C_content_version: 1.0; RSen_C_intended_use: Entwässerungssysteme
Type - Identity Data - Description: ACO viewing window; LOD: LOD 400; Manufacturer: ACO; Model: Viewing window; OmniClass Number: 23.70.50.00; OmniClass Title: Liquid Waste Handling Services; Type Comments: Nominal width: DN 200; Type Name: std
Type - Materials and Finishes - RSen_C_material: HDPE, Grey
Type - Other - Category: Mechanical Equipment; Family Name: ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO
Type - Structural - RSen_S_net_mass: 5
OverallHeight: 75 mm; OverallWidth: 250 mm
Pset_WindowCommon - Reference: std; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ACO
Constraints - Moves With Nearby Elements: no; Host: Level : Level 0; Level: Level: Level 0
Dimensions - Area: 0.0878948 m2; Volume: 0.00175086 m3
Identity Data - RSen_C_code_article: 3300.11.10; RSen_C_code_gtin: 04002626130280; RSen_C_description: ACO Schauglas LW 200 f. LipuJet-P-OB,-P-OD,-P-RB,-P-RD; RSen_C_product_assortment: Grease separators
Other - Family: ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO: std; Family and Type: ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO: std; option: 0; Type: ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO: std; Type Id: ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO: std
Phasing - Phase Created: New Construction
Name (ZZZ_do not use_ME_PE_WPB_viewing window LipuJet-P_ACO:std:...) | Offset (mm) | Mark
298657 | 705 | 3
298658 | 1147 | 4
